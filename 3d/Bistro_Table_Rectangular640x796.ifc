Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-12-21T08:51:46
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 21 08:51:46 2018 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{C7B3AB89-0B03-4644-B1CC-0965B5924AF0}\ifc * Database version: 5507 * Database creation date: Fri Dec 21 08:51:46 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 21 08:51:46 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 21 08:51:46 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Bistro table rectangular 640x796mm, CONV_Vitra_Tbls_Bistro_Rectangular640x796:Bistro table rectangular 640x796mm:441546
In: Level 1
Material: 01 white (textured), 30 basic dark powder-coated
Pset_ManufacturerTypeInformation - ModelReference: 44300600; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.69496 m2; Volume: 0.424109 m3
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: CONV_Vitra_Tbls_Bistro_Rectangular640x796: Bistro table rectangular 640x796mm; Family and Type: CONV_Vitra_Tbls_Bistro_Rectangular640x796: Bistro table rectangular 640x796mm; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: CONV_Vitra_Tbls_Bistro_Rectangular640x796: Bistro table rectangular 640x796mm; Type Id: CONV_Vitra_Tbls_Bistro_Rectangular640x796: Bistro table rectangular 640x796mm; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
General(Type) - Author: Convergo AB; BIMObjectName: CONV_Vitra_Tbls_Bistro_Rectangular640x796; ConvergoRefNr: 0089-1812-0171-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Tables; NBSReference: 45-35-86/327; ProductInformation: Featuring an elegant cruciform base and understated design, the Bistro Table (2009/2010) by Ronan and Erwan Bouroullec is also suited for outdoor use in the version with a solid core table top.; Revision: n/a; Uniclass2: Pr_40_50_21_21; Uniclass2015Description: Dining tables; Uniclass2015Reference: Pr_40_50_21_22; Version: 1; VersionDate: 20/12/2018
Identity Data(Type) - Collection: Bistro; Cost: 0; Description: Featuring an elegant cruciform base and understated design, the Bistro Table (2009/2010) by Ronan and Erwan Bouroullec is also suited for outdoor use in the version with a solid core table top.; Designer: Ronan & Erwan Bouroullec; Manufacturer: Vitra; Model: Bistro table rectangular 640x796mm; OmniClass Number: 23.40.20.14.17.11; OmniClass Title: Dining Room Tables; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/184130/storage/master/download/FS_Bistro_Table-EN_preview.pdf; Type Name: Bistro table rectangular 640x796mm; URL: https://www.vitra.com/en-un/living/product/details/bistro-table
Materials and Finishes(Type) - TableMainMaterial: 01 white (textured); TableSecondaryMaterial: 30 basic dark powder-coated
Other(Type) - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Tables; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: CONV_Vitra_Tbls_Bistro_Rectangular640x796; Features: The glides can be adjusted (max. extension 10 mm) for levelling on uneven floors.; Finish: Table tops available in three materials: melamine faced, white surface, smooth straight plastic edge (19 mm); light or dark oak veneer (Europe) (19 mm); solid core laminate in the colours white, pastel grey or black with black edge (12 mm). The solid core table top in black has an additional anti-fingerprint coating. Base: powder-coated in basic dark (RAL 9004).; Grade: n/a; Material: Melanine/laminate & metal; ModelNumber: n/a; ModelReference: 44300600; Name: Tbls_Bistro_Rectangular640x796; ReplacementCost: n/a; Shape: Sculptured; Size: 640x796x740 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
